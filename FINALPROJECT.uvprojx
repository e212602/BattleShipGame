# Keil uVision project FINALPROJECT.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FINALPROJECT
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: DELAY100.s MainProgram.s Startup.s InitializationOfSSI.s Border.s PrintNumber.s ADCInit.s Calibrator.s Buttons.s DISPLAY_NEW.s ICON.s ClearPrev.s player2.s system_timer.s fifo.s ships_display.s Pulse.s decision_maker.s mine_viccinity-check.s x_display.s
